# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __RTTHREAD__, STM32H743xx
  c include: rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;packages\gt9147-latest\inc;.;rt-thread\include;rt-thread\components\libc\compilers\common;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;packages\touchgfx2rtt-latest\TouchGFX\App;packages\touchgfx2rtt-latest\TouchGFX\target;packages\touchgfx2rtt-latest\TouchGFX\target\generated;packages\touchgfx2rtt-latest\Middlewares\ST\touchgfx\framework\include;packages\touchgfx2rtt-latest\TouchGFX\generated\fonts\include;packages\touchgfx2rtt-latest\TouchGFX\generated\gui_generated\include;packages\touchgfx2rtt-latest\TouchGFX\generated\images\include;packages\touchgfx2rtt-latest\TouchGFX\generated\texts\include;packages\touchgfx2rtt-latest\TouchGFX\gui\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c drv_mpu.c
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_sdram.c drv_lcd.c drv_common.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group gt9147
    packages/gt9147-latest/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c
  group Touch
    rt-thread/components/drivers/touch/: touch.c
  group TouchGFX_app
    packages/touchgfx2rtt-latest/TouchGFX/target/generated/: OSWrappers_RTT.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp
    packages/touchgfx2rtt-latest/TouchGFX/target/: STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
    packages/touchgfx2rtt-latest/TouchGFX/App/: app_touchgfx.c
    packages/touchgfx2rtt-latest/examples/: touchgfx_main.c
    packages/touchgfx2rtt-latest/Middlewares/ST/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group TouchGFX_generated
    packages/touchgfx2rtt-latest/TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp FontCache.cpp Font_FZSTK_TTF_25_4bpp_0.cpp Font_FZSTK_TTF_25_4bpp_10.cpp Font_FZSTK_TTF_25_4bpp_11.cpp Font_FZSTK_TTF_25_4bpp_13.cpp Font_FZSTK_TTF_25_4bpp_14.cpp Font_FZSTK_TTF_25_4bpp_15.cpp Font_FZSTK_TTF_25_4bpp_4.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp GeneratedFont.cpp Kerning_FZSTK_TTF_25_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_FZSTK_TTF_25_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/gui_generated/src/containers/: CustomContainer_IConBase.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/gui_generated/src/mainscreen_screen/: MainScreenViewBase.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/images/src/: BitmapDatabase.cpp image_bishe_back.cpp image_image00_0.cpp image_image00_1.cpp image_image01_0.cpp image_image01_1.cpp image_image02_0.cpp image_image02_1.cpp image_image03_0.cpp image_image03_1.cpp image_image04_0.cpp image_image04_1.cpp image_image05_0.cpp image_image05_1.cpp image_image06_0.cpp image_image06_1.cpp image_image07_0.cpp image_image07_1.cpp image_image08_0.cpp image_image08_1.cpp image_image09_0.cpp image_image09_1.cpp image_image100_0.cpp image_image100_1.cpp image_image10_0.cpp image_image10_1.cpp image_image11_0.cpp image_image11_1.cpp image_image12_0.cpp image_image12_1.cpp image_image13_0.cpp image_image13_1.cpp image_image14_0.cpp image_image14_1.cpp image_image15_0.cpp image_image15_1.cpp image_image16_0.cpp image_image16_1.cpp image_image17_0.cpp image_image17_1.cpp image_image18_0.cpp image_image18_1.cpp image_image19_0.cpp image_image19_1.cpp image_image20_0.cpp image_image20_1.cpp image_image21_0.cpp image_image21_1.cpp image_image22_0.cpp image_image22_1.cpp image_image23_0.cpp image_image23_1.cpp image_image24_0.cpp image_image24_1.cpp image_image25_0.cpp image_image25_1.cpp image_image26_0.cpp image_image26_1.cpp image_image27_0.cpp image_image27_1.cpp image_image28_0.cpp image_image28_1.cpp image_image29_0.cpp image_image29_1.cpp image_image30_0.cpp image_image30_1.cpp image_image31_0.cpp image_image31_1.cpp image_image32_0.cpp image_image32_1.cpp image_image49_0.cpp image_image49_1.cpp image_image53_0.cpp image_image53_1.cpp image_image54_0.cpp image_image54_1.cpp image_image55_0.cpp image_image55_1.cpp image_image56_0.cpp image_image56_1.cpp image_image57_0.cpp image_image57_1.cpp image_image58_0.cpp image_image58_1.cpp image_image99_0.cpp image_image99_1.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX_gui
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/common/: FrontendApplication.cpp
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/containers/: CustomContainer_ICon.cpp
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/mainscreen_screen/: MainScreenPresenter.cpp MainScreenView.cpp
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX_resource
    packages/touchgfx2rtt-latest/TouchGFX/generated/images/src/__designer/: image_Blue_Clocks_Backgrounds_clock_classic_background.cpp image_Blue_Clocks_Hands_clock_standard_hour_hand.cpp image_Blue_Clocks_Hands_clock_standard_minute_hand.cpp image_Blue_Clocks_Hands_clock_standard_second_hand.cpp
